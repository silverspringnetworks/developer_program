/*

Copyright (c) Silver Spring Networks, Inc. 
All rights reserved.

Permission is hereby granted, free of charge, to any person obtaining a copy of
this software and associated documentation files (the ""Software""), to deal in
the Software without restriction, including without limitation the rights to
use, copy, modify, merge, publish, distribute, sublicense, and/or sell copies of 
the Software, and to permit persons to whom the Software is furnished to do so, 
subject to the following conditions:

The above copyright notice and this permission notice shall be included in all 
copies or substantial portions of the Software.

THE SOFTWARE IS PROVIDED AS IS, WITHOUT WARRANTY OF ANY KIND, EXPRESS OR
IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF MERCHANTABILITY, FITNESS
FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT. IN NO EVENT SHALL THE AUTHORS OR
COPYRIGHT HOLDERS BE LIABLE FOR ANY CLAIM, DAMAGES OR OTHER LIABILITY, WHETHER
IN AN ACTION OF CONTRACT, TORT OR OTHERWISE, ARISING FROM, OUT OF OR IN
CONNECTION WITH THE SOFTWARE OR THE USE OR OTHER DEALINGS IN THE SOFTWARE.

Except as contained in this notice, the name of Silver Spring Networks, Inc. 
shall not be used in advertising or otherwise to promote the sale, use or other 
dealings in this Software without prior written authorization from Silver Spring
Networks, Inc.

*/

/*
 * Copyright SilverSpring Networks 2004.
 * All rights reserved.
 *
 * $Id: crc_xmodem.c 102877 2016-10-11 21:35:02Z zkiss $
 */

#include "crc_xmodem.h"

/*
 * CRC LOOKUP TABLE
 * ================
 *    Width   : 2 bytes.
 *    Poly    : 0x1021
 *    Reverse : TRUE.
 */
static const uint16_t xmodem_crctable[256]  = {
    0x0000, 0x1189, 0x2312, 0x329b, 0x4624, 0x57ad, 0x6536, 0x74bf,
    0x8c48, 0x9dc1, 0xaf5a, 0xbed3, 0xca6c, 0xdbe5, 0xe97e, 0xf8f7,
    0x1081, 0x0108, 0x3393, 0x221a, 0x56a5, 0x472c, 0x75b7, 0x643e,
    0x9cc9, 0x8d40, 0xbfdb, 0xae52, 0xdaed, 0xcb64, 0xf9ff, 0xe876,
    0x2102, 0x308b, 0x0210, 0x1399, 0x6726, 0x76af, 0x4434, 0x55bd,
    0xad4a, 0xbcc3, 0x8e58, 0x9fd1, 0xeb6e, 0xfae7, 0xc87c, 0xd9f5,
    0x3183, 0x200a, 0x1291, 0x0318, 0x77a7, 0x662e, 0x54b5, 0x453c,
    0xbdcb, 0xac42, 0x9ed9, 0x8f50, 0xfbef, 0xea66, 0xd8fd, 0xc974,
    0x4204, 0x538d, 0x6116, 0x709f, 0x0420, 0x15a9, 0x2732, 0x36bb,
    0xce4c, 0xdfc5, 0xed5e, 0xfcd7, 0x8868, 0x99e1, 0xab7a, 0xbaf3,
    0x5285, 0x430c, 0x7197, 0x601e, 0x14a1, 0x0528, 0x37b3, 0x263a,
    0xdecd, 0xcf44, 0xfddf, 0xec56, 0x98e9, 0x8960, 0xbbfb, 0xaa72,
    0x6306, 0x728f, 0x4014, 0x519d, 0x2522, 0x34ab, 0x0630, 0x17b9,
    0xef4e, 0xfec7, 0xcc5c, 0xddd5, 0xa96a, 0xb8e3, 0x8a78, 0x9bf1,
    0x7387, 0x620e, 0x5095, 0x411c, 0x35a3, 0x242a, 0x16b1, 0x0738,
    0xffcf, 0xee46, 0xdcdd, 0xcd54, 0xb9eb, 0xa862, 0x9af9, 0x8b70,
    0x8408, 0x9581, 0xa71a, 0xb693, 0xc22c, 0xd3a5, 0xe13e, 0xf0b7,
    0x0840, 0x19c9, 0x2b52, 0x3adb, 0x4e64, 0x5fed, 0x6d76, 0x7cff,
    0x9489, 0x8500, 0xb79b, 0xa612, 0xd2ad, 0xc324, 0xf1bf, 0xe036,
    0x18c1, 0x0948, 0x3bd3, 0x2a5a, 0x5ee5, 0x4f6c, 0x7df7, 0x6c7e,
    0xa50a, 0xb483, 0x8618, 0x9791, 0xe32e, 0xf2a7, 0xc03c, 0xd1b5,
    0x2942, 0x38cb, 0x0a50, 0x1bd9, 0x6f66, 0x7eef, 0x4c74, 0x5dfd,
    0xb58b, 0xa402, 0x9699, 0x8710, 0xf3af, 0xe226, 0xd0bd, 0xc134,
    0x39c3, 0x284a, 0x1ad1, 0x0b58, 0x7fe7, 0x6e6e, 0x5cf5, 0x4d7c,
    0xc60c, 0xd785, 0xe51e, 0xf497, 0x8028, 0x91a1, 0xa33a, 0xb2b3,
    0x4a44, 0x5bcd, 0x6956, 0x78df, 0x0c60, 0x1de9, 0x2f72, 0x3efb,
    0xd68d, 0xc704, 0xf59f, 0xe416, 0x90a9, 0x8120, 0xb3bb, 0xa232,
    0x5ac5, 0x4b4c, 0x79d7, 0x685e, 0x1ce1, 0x0d68, 0x3ff3, 0x2e7a,
    0xe70e, 0xf687, 0xc41c, 0xd595, 0xa12a, 0xb0a3, 0x8238, 0x93b1,
    0x6b46, 0x7acf, 0x4854, 0x59dd, 0x2d62, 0x3ceb, 0x0e70, 0x1ff9,
    0xf78f, 0xe606, 0xd49d, 0xc514, 0xb1ab, 0xa022, 0x92b9, 0x8330,
    0x7bc7, 0x6a4e, 0x58d5, 0x495c, 0x3de3, 0x2c6a, 0x1ef1, 0x0f78
};

/*
 * CRC LOOKUP TABLE CRC-16-DNP for DNP3, IEC 870, M-Bus
 * ================
 *    Width   : 2 bytes.
 *    Poly    : 0xA6BC
 *    Reverse : TRUE.
 *
 *    Generated with this funciton:
 *    static uint16_t
 *    dnp3_crc_table(uint8_t idx)
 *    {
 *        uint16_t val;
 *        int i;
 *
 *        val = idx % 256;
 *        for (i = 0; i < 8; ++i) {
 *            val = val & 1 ? (val >> 1) ^ 0xa6bc : val >> 1;
 *        }
 *
 *        return val;
 *    }
 */
static const uint16_t dnp_crctable[256] = {
        0x0000,0x365e,0x6cbc,0x5ae2,0xd978,0xef26,0xb5c4,0x839a,
        0xff89,0xc9d7,0x9335,0xa56b,0x26f1,0x10af,0x4a4d,0x7c13,
        0xb26b,0x8435,0xded7,0xe889,0x6b13,0x5d4d,0x7af,0x31f1,
        0x4de2,0x7bbc,0x215e,0x1700,0x949a,0xa2c4,0xf826,0xce78,
        0x29af,0x1ff1,0x4513,0x734d,0xf0d7,0xc689,0x9c6b,0xaa35,
        0xd626,0xe078,0xba9a,0x8cc4,0xf5e,0x3900,0x63e2,0x55bc,
        0x9bc4,0xad9a,0xf778,0xc126,0x42bc,0x74e2,0x2e00,0x185e,
        0x644d,0x5213,0x8f1,0x3eaf,0xbd35,0x8b6b,0xd189,0xe7d7,
        0x535e,0x6500,0x3fe2,0x9bc,0x8a26,0xbc78,0xe69a,0xd0c4,
        0xacd7,0x9a89,0xc06b,0xf635,0x75af,0x43f1,0x1913,0x2f4d,
        0xe135,0xd76b,0x8d89,0xbbd7,0x384d,0xe13,0x54f1,0x62af,
        0x1ebc,0x28e2,0x7200,0x445e,0xc7c4,0xf19a,0xab78,0x9d26,
        0x7af1,0x4caf,0x164d,0x2013,0xa389,0x95d7,0xcf35,0xf96b,
        0x8578,0xb326,0xe9c4,0xdf9a,0x5c00,0x6a5e,0x30bc,0x6e2,
        0xc89a,0xfec4,0xa426,0x9278,0x11e2,0x27bc,0x7d5e,0x4b00,
        0x3713,0x14d,0x5baf,0x6df1,0xee6b,0xd835,0x82d7,0xb489,
        0xa6bc,0x90e2,0xca00,0xfc5e,0x7fc4,0x499a,0x1378,0x2526,
        0x5935,0x6f6b,0x3589,0x3d7,0x804d,0xb613,0xecf1,0xdaaf,
        0x14d7,0x2289,0x786b,0x4e35,0xcdaf,0xfbf1,0xa113,0x974d,
        0xeb5e,0xdd00,0x87e2,0xb1bc,0x3226,0x478,0x5e9a,0x68c4,
        0x8f13,0xb94d,0xe3af,0xd5f1,0x566b,0x6035,0x3ad7,0xc89,
        0x709a,0x46c4,0x1c26,0x2a78,0xa9e2,0x9fbc,0xc55e,0xf300,
        0x3d78,0xb26,0x51c4,0x679a,0xe400,0xd25e,0x88bc,0xbee2,
        0xc2f1,0xf4af,0xae4d,0x9813,0x1b89,0x2dd7,0x7735,0x416b,
        0xf5e2,0xc3bc,0x995e,0xaf00,0x2c9a,0x1ac4,0x4026,0x7678,
        0xa6b,0x3c35,0x66d7,0x5089,0xd313,0xe54d,0xbfaf,0x89f1,
        0x4789,0x71d7,0x2b35,0x1d6b,0x9ef1,0xa8af,0xf24d,0xc413,
        0xb800,0x8e5e,0xd4bc,0xe2e2,0x6178,0x5726,0xdc4,0x3b9a,
        0xdc4d,0xea13,0xb0f1,0x86af,0x535,0x336b,0x6989,0x5fd7,
        0x23c4,0x159a,0x4f78,0x7926,0xfabc,0xcce2,0x9600,0xa05e,
        0x6e26,0x5878,0x29a,0x34c4,0xb75e,0x8100,0xdbe2,0xedbc,
        0x91af,0xa7f1,0xfd13,0xcb4d,0x48d7,0x7e89,0x246b,0x1235
};
/*
 * Initialize CRC value.
 */
uint16_t
crc_xmodem_init(void)
{
    return (0xffff);
}

/*
 * Append data block to CRC.
 */
uint16_t
crc_xmodem(uint16_t crc, const void *addr_v, unsigned int len)
{
    const uint8_t *addr = (const uint8_t *)addr_v;
    uint8_t ch;

    while (len--) {
        ch = *addr++;
        crc = xmodem_crctable[crc & 0xff] ^ (crc >> 8) ^ (ch << 8);
    }
    return (crc);
}

/* This implementation matches PPP FCS calculation, also used for HDLC
 * The resulting 16 bit value needs to be inverted and appended LSB first 
 * after the data buffer.
 * CRC of the resulting buffer will yield F0B8 in absence of errors.
 */
#define CRC16_INITIAL   (0xffff)  /* Initial FCS value */

uint16_t
crc16_init(void)
{
    return CRC16_INITIAL;
}

uint16_t
crc16(uint16_t crc, const  void *addr_v, unsigned int len)
{
    const uint8_t *addr = (const uint8_t *)addr_v;
    uint8_t ch;

    while (len--) {
        ch = *addr++;
        crc = (crc >> 8) ^ xmodem_crctable[(crc ^ ch) & 0xFF]; 

    }
    return crc;
}    


/* len includes the 2 bytes of CRC at the end of the buffer 
 * return 0 for OK, nonzero for error
 */
int
crc16_validate(const void *addr_v, unsigned int len)
{
    return (crc16(CRC16_INITIAL, addr_v, len) != CRC16_FINAL);         
}


uint16_t
crc_dnp(const uint8_t *data, int len)
{
    uint16_t crc;
    int i;

    crc = 0;
    for (i = 0; i < len; ++i) {
        crc = crc >> 8 ^ dnp_crctable[(crc ^ data[i])&0xFF];
    }

    return ~crc;
}


